# Keil uVision project Project.uvprojx, settings and files
target Loader (6240000::V6.24::ARMCLANG)
  device: STM32H553ZGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00034000) IRAM2(0x20034000,0x0004C000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Loader
  AfterMake: fromelf #L --bin --output=..\Binary\Loader.bin
  AfterMake: postbuild.bat
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H553xx,USE_HAL_DRIVER,LOCAL_LOADER_CONFIG,BL2,USB_CDC_SUPPORT
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include;..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc;..\..\OEMiROT_Boot\Inc;..\USB_Device\App;..\USB_Device\Target;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x34000
  memory RVCT10: RAM 0x20034000 size 0x4c000
  scatter file: .\stm32h5xx_flash_s.sct
  link misc: --predefine=-I../../OEMiROT_Boot/Inc
--predefine=-DBL2
--predefine=-DSTM32H5635xx
--import_cmse_lib_out=Loader/Exe/Project_import_lib.o
  group Application/User
    ../Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c ymodem.c stm32h5xx_it.c stm32h5xx_hal_msp.c
    ./: startup_stm32h553xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx_s.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c stm32h5xx_hal_icache.c stm32h5xx_hal_gtzc.c
  group Application/User/USB_Device
    ../USB_Device/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
    ../USB_Device/Target/: usbd_conf.c
  group Middlewares/ST_USBD_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.1
