<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OEMiROT_Boot\EWARM\Project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\OEMiROT_Appli_TrustZone\EWARM\Secure\Project_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\OEMiROT_Appli_TrustZone\EWARM\NonSecure\Project_ns.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>Project</project>
                <configuration>NUCLEO-H563ZI_OEMiROT_Boot</configuration>
            </member>
            <member>
                <project>Project_s</project>
                <configuration>NUCLEO-H563ZI_OEMiROT_Appli_TrustZone_S</configuration>
            </member>
            <member>
                <project>Project_ns</project>
                <configuration>NUCLEO-H563ZI_OEMiROT_Appli_TrustZone_NS</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
