<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Secure\Project_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NonSecure\Project_ns.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>Project_s</project>
                <configuration>NUCLEO-H563ZI_OEMiROT_Appli_TrustZone_S</configuration>
            </member>
            <member>
                <project>Project_ns</project>
                <configuration>NUCLEO-H563ZI_OEMiROT_Appli_TrustZone_NS</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
