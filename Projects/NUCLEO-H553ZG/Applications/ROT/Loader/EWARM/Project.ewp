# IAR project Project.ewp, settings and files
configuration Loader (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx; LOCAL_LOADER_CONFIG; BL2
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\..\Linker; ..\Inc; ..\..\OEMiROT_Boot\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../Binary/Loader.hex
  prebuild: prebuild.cmd "$PROJ_DIR$" "STM32H573xx"
  ILINK.IlinkOutputFile: loader.out
  ILINK.IlinkIcfFile: flash.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c startup_stm32h5xx.c tick.c ymodem.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
