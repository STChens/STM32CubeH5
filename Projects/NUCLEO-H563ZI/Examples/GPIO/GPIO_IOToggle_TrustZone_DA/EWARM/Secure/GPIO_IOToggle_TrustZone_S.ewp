# IAR project GPIO_IOToggle_TrustZone_S.ewp, settings and files
configuration GPIO_IOToggle_TrustZone_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx
  ICCARM.CCIncludePath2: ../../Secure/Inc; ../../Secure_nsclib; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_IOToggle_TrustZone_S.hex
  ILINK.IlinkOutputFile: GPIO_IOToggle_TrustZone_S.out
  ILINK.IlinkIcfFile: stm32h563xx_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User/Secure
    ../../Secure/Src/: low_level_obkeys.c low_level_obkeys_device.c main.c secure_nsc.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32h5xx_s.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_hash.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
