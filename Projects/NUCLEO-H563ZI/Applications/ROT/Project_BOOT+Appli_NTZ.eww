<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OEMiROT_Boot\EWARM_NTZ\Project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\OEMiROT_Appli\EWARM_NTZ\Project.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>Project</project>
                <configuration>NUCLEO-H563ZI_OEMiROT_Boot</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>NUCLEO-H563ZI_OEMiROT_Appli</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
