# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-H563ZI_OEMiROT_Appli (6210000::V6.21::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x30000000,0x040000) IROM(0x08000000,0x00200000) IROM2(0x0C000000,0x00200000) XRAM(0x20040000,0x00010000) XRAM2(0x20050000,0x00050000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\rot_tz_s_app.bin"
  AfterMake: .\postbuild.bat "secure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H563xx,USE_HAL_DRIVER
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../Inc;../Secure_nsclib;..\..\..\..\..\..\Drivers\BSP\STM32H5xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x10000
  memory RVCT7: RAM 0x20050000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: stm32h563xx.sct
  group Doc
    ../: README.md
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Application/User
    ../Src/: main.c low_level_security.c loader.c stm32h5xx_it.c low_level_flash.c low_level_device.c
    ./: startup_stm32h563xx.s
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
software components: CMSIS:CORE 5.6.0
