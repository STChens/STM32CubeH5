<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\OEMiROT_Boot\EWARM\Project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\OEMuROT_Boot\EWARM\Project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\OEMuROT_Appli\EWARM\Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>
