# Keil uVision project Project_s.uvprojx, settings and files
target NUCLEO-H553ZG_OEMiROT_Appli (6240000::V6.24::ARMCLANG)
  device: STM32H553ZGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00034000) IRAM2(0x20034000,0x0004C000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bincombined --output=..\Binary\rot_tz_s_app.bin
  AfterMake: postbuild.bat "secure"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H553xx,USE_HAL_DRIVER
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include;..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc;..\..\OEMiROT_Boot\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x34000
  memory RVCT10: RAM 0x20034000 size 0x4c000
  scatter file: stm32h553xx.sct
  group Application/User
    ../Src/: com.c common.c main.c loader.c low_level_device.c low_level_flash.c stm32h5xx_it.c
    ./: startup_stm32h553xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx_s.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_gtzc.c
software components: CMSIS:CORE 6.1.1
